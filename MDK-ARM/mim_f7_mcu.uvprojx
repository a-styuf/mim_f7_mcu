# Keil uVision project mim_f7_mcu.uvprojx, settings and files
target mim_f7_mcu (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: mim_f7_mcu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../aa_lib;../my_files
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c fmc.c iwdg.c rtc.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_can.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nor.c stm32f7xx_hal_sram.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group my_files
    ../my_files/: byteswap.c clock.c crc16.c cyclogramma.c debug.c experiment.c flight_task.c frames.c mim.c mim_rs485_tr_lvl.c mim_rs485_tr_lvl_data_map.c modbus.c modbus_interface.c my_gpio.c nand.c pwr.c pwr_ch.c radio.c segmented_data.c sys_uart.c task_planner.c xtime.c cy15b104qn_spi.c ext_mem.c
  group aa_lib
    ../aa_lib/: canv.c canvar.c fw_ver.inc
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0
